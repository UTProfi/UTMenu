# IAR project UtMenuTests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Inc; ..\UI\lowLevel; ..\UI\menu; ..\UI\windows; ..\UI; ..\Tests\Unity\unity_fixtures; ..\Tests\Unity
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Tests/: main.c
  group Tests
    ../Tests/: MenuWindowTests.c
  group Unity
    ../Tests/Unity/: unity.c unity.h unity_internals.h
  group Unity/unity_fixtures
    ../Tests/Unity/unity_fixtures/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group UtMenu_Code/lowLevel
    ../UI/lowLevel/: canvas.c canvas.h fonts.c fonts.h layout.c layout.h stack.c stack.h
  group UtMenu_Code/menu
    ../UI/menu/: menu.c menu.h
  group UtMenu_Code/windows
    ../UI/windows/: menu_window.c menu_window.h
